# IAR project Project.ewp, settings and files
configuration STM3210E_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xG ST STM32F103xG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xG; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM3210E_EVAL; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3210E_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f103xg_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c joystick.c lcd.c sd.c log.c stm32f1xx_it.c audio_play.c temperature_sensor.c nor.c sram.c nand.c flash.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Example/EWARM
    ./: startup_stm32f103xg.s
  group Drivers/BSP/STM3210E_EVAL
    ../../../../../Drivers/BSP/STM3210E_EVAL/: stm3210e_eval.c stm3210e_eval_lcd.c stm3210e_eval_sd.c stm3210e_eval_audio.c stm3210e_eval_nor.c stm3210e_eval_sram.c stm3210e_eval_nand.c stm3210e_eval_serialflash.c stm3210e_eval_tsensor.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hx8347d/: hx8347d.c
    ../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../Drivers/BSP/Components/spfd5408/: spfd5408.c
    ../../../../../Drivers/BSP/Components/stlm75/: stlm75.c
    ../../../../../Drivers/BSP/Components/ak4343/: ak4343.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_i2s.c stm32f1xx_hal_sram.c stm32f1xx_hal_nor.c stm32f1xx_hal_nand.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
