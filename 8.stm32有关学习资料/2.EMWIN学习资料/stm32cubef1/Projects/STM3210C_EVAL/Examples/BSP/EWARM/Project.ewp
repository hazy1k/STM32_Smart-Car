# IAR project Project.ewp, settings and files
configuration STM3210C_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F107xC; USE_STM3210C_EVAL
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include; ..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\BSP\STM3210C_EVAL; ..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\Utilities\Log; ..\..\..\..\..\Utilities\CPU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3210C_EVAL.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f107xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Example/User
    ../Src/: main.c joystick.c lcd.c sd.c log.c stm32f1xx_it.c audio_play.c eeprom.c mems.c touchscreen.c ts_calibration.c
  group Example/Utilities
    ../../../../../Utilities/Log/: lcd_log.c
  group Example/EWARM
    ./: startup_stm32f107xc.s
  group Drivers/BSP/STM3210C_EVAL
    ../../../../../Drivers/BSP/STM3210C_EVAL/: stm3210c_eval.c stm3210c_eval_lcd.c stm3210c_eval_sd.c stm3210c_eval_audio.c stm3210c_eval_eeprom.c stm3210c_eval_audio.c stm3210c_eval_io.c stm3210c_eval_ts.c stm3210c_eval_accelerometer.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/cs43l22/: cs43l22.c
    ../../../../../Drivers/BSP/Components/ili9320/: ili9320.c
    ../../../../../Drivers/BSP/Components/ili9325/: ili9325.c
    ../../../../../Drivers/BSP/Components/lis302dl/: lis302dl.c
    ../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_i2s.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
