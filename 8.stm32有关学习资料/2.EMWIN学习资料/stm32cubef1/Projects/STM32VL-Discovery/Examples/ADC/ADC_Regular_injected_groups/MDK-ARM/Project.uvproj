# Keil uVision project Project.uvproj, settings and files
target STM32VL-Discovery (ARM-ADS)
  device: STM32F100VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32VL-Discovery
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F100xB,USE_STM32VL_DISCO,
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\..\..\..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32VL-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32VL-Discovery
    ../../../../../../Drivers/BSP/STM32VL-Discovery/: stm32vl_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../../../../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Example/MDK-ARM
    ./: startup_stm32f100xb.s
  group Example/User
    ../Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
