<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\STemWinDemo.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Buil_All</name>
      <member>
        <project>STemWinDemo</project>
        <configuration>STM3210E-EVAL</configuration>
      </member>
      <member>
        <project>STemWinDemo</project>
        <configuration>STM324x9I-EVAL-MB1046</configuration>
      </member>
      <member>
        <project>STemWinDemo</project>
        <configuration>STM324x9I-EVAL-MB1063</configuration>
      </member>
      <member>
        <project>STemWinDemo</project>
        <configuration>STM324xG-EVAL</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


