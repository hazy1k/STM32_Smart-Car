# IAR project STemWinDemo.ewp, settings and files
configuration STM32373C-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F373xC ST STM32F373xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; USE_STM32373C_EVAL; STM32F37X
  ICCARM.CCIncludePath2: ..\Config; ..\User; ..\Demo; ..\..\..\..\Libraries\STM32F37x_StdPeriph_Driver\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F37x\Include; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32373C_EVAL; ..\..\..\..\Utilities\Third_Party\fat_fs\inc; ..\..\..\..\Libraries\STemWinLibrary522\inc; ..\..\..\..\Libraries\STemWinLibrary522\Config; ..\..\..\..\Utilities\Third_Party\FreeRTOS\Source\portable\IAR\ARM_CM4F; ..\..\..\..\Utilities\Third_Party\FreeRTOS\Source\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Config
  OBJCOPY.OOCOutputFile: STemWinDemo_STM32373C_FreeRTOS.hex
  ILINK.IlinkOutputFile: STM32373C-EVAL.out
  ILINK.IlinkIcfFile: stm32f37x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Appli/Demo
    ../Demo/: GUIDEMO.c GUIDEMO.h GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group Appli/User
    ../User/: bsp.c main.c startup_stm32f37x.s stm32xxx_it.c system_stm32f37x.c
  group Libraries/STemWin_V522/Config
    ../Config/: GUIConf_stm32373c_eval.c LCDConf_stm32373c_eval.c
  group Libraries/STemWin_V522/inc
    ../../../../Libraries/STemWinLibrary522/inc/: BUTTON.h BUTTON_Private.h CALENDAR.h CHECKBOX.h CHECKBOX_Private.h CHOOSECOLOR.h CHOOSEFILE.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_SetOrientation.h GUI_SetOrientationCX.h GUI_SPRITE_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUIDRV_DCache.h GUIDRV_DCache_Private.h GUIDRV_Dist.h GUIDRV_FlexColor.h GUIDRV_FlexColor_Private.h GUIDRV_Generic.h GUIDRV_Lin.h GUIDRV_Lin_Opt_16.h GUIDRV_Lin_Opt_24.h GUIDRV_Lin_Opt_32.h GUIDRV_Lin_Opt_8.h GUIDRV_Lin_Private.h GUIDRV_NoOpt_1_8.h GUIDRV_Template.h GUIDRV_TemplateI.h GUIDRV_TemplateI_Private.h HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h IMAGE.h IMAGE_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h SPINBOX.h SPINBOX_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group Libraries/STemWin_V522/Lib
    ../../../../Libraries/STemWinLibrary522/Lib/: STemWin522_CM4_OS_IAR.a
  group Libraries/STemWin_V522/OS
    ../../../../Libraries/STemWinLibrary522/OS/: GUI_X_FreeRTOS.c
  group Libraries/STM32373C-EVAL
    ../../../../Utilities/STM32_EVAL/STM32373C_EVAL/: stm32373c_eval.c stm32373c_eval_lcd.c
  group Libraries/STM32F37x_StdPeriph_Driver
    ../../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_adc.c stm32f37x_can.c stm32f37x_cec.c stm32f37x_comp.c stm32f37x_crc.c stm32f37x_dac.c stm32f37x_dbgmcu.c stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_iwdg.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_rtc.c stm32f37x_sdadc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_tim.c stm32f37x_usart.c stm32f37x_wwdg.c
  group Utilities/FreeRTOS/Core
    ../../../../Utilities/Third_Party/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
  group Utilities/FreeRTOS/Memory
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_2.c
  group Utilities/FreeRTOS/Portable/ARM_CM4F
    ../../../../Utilities/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port_cm4.c portasm_cm4.s
